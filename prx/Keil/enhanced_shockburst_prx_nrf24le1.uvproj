# Keil uVision project enhanced_shockburst_prx_nrf24le1.uvproj, settings and files
target PRX (MCS-51)
  device: nRF24LE1 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) XRAM2(0xFA00-0xFFFF) CLOCK(24000000) MODC2 MDU_R515
  output: enhanced_shockburst_prx_nrf24le1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: MCU_NRF24LE1
  c include: ..\..\hal\nrf24le1;..\..\hal\nrf24l01p;..\..\hal;..\..\compiler\c51;..\..\compiler\common
  group App
    C:/dev/livewrist/prx/: main.c
  group HAL
    C:/dev/livewrist/hal/nrf24le1/: hal_nrf_hw.c hal_clk.c
    C:/dev/livewrist/hal/nrf24l01p/: hal_nrf.c
    ../../hal/nrf24le1/: hal_uart.c
    ../../hal/: hal_delay.c
